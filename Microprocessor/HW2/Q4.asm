
/*first program*/
.DEF INPUT = R20
.DEF CTR = R19

LDI INPUT, 0X57

LDI CTR, 0X00
MOV R21, INPUT
LOOP: 
CPI R21, 0X00
BREQ END
SBRC R21, 0
INC CTR
LSR R21
RJMP LOOP
END:  RJMP END


/*second program*/
.DEF INPUT = R20
.DEF CTR = R19

LDI INPUT, 0X57

LDI CTR, 0X00
SBRC INPUT, 0
INC CTR
SBRC INPUT, 1
INC CTR
SBRC INPUT, 2
INC CTR
SBRC INPUT, 3
INC CTR
SBRC INPUT, 4
INC CTR
SBRC INPUT, 5
INC CTR
SBRC INPUT, 6
INC CTR
SBRC INPUT, 7
INC CTR
END: RJMP END


/*third program*/
.DEF INPUT = R20
	.DEF CTR = R19

	LDI CTR, 0x08
	LDI INPUT, 0X57
	LDI R18, 0b10000000
AGAIN:	
	MOV R21, INPUT
	AND R21, R18
	BREQ DECREASE
CHECK_END:
	CPI R18, 0b00000001
	BREQ END
	LSR R18
	RJMP AGAIN

DECREASE:	
	DEC CTR
	RJMP CHECK_END

END: RJMP END

